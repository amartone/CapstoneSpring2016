# IAR project ImpedanceRtos.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM350BBCZ AnalogDevices ADUCM350BBCZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: ADI_DEBUG; ARM_MATH_CM3; RELOCATE_IVT; ADI_SYSTEM_CLOCK_TRANSITION; OSAL_DEBUG
  ICCARM.CCDiagSuppress: Pa050, Pe161
  ICCARM.IExtraOptions: --diag_suppress Pe1665
  ICCARM.CCIncludePath2: ..; ..\..\Eval-ADUCM350EBZ\inc; ..\..\Eval-ADUCM350EBZ\inc\config; ..\..\Eval-ADUCM350EBZ\osal\uCOS-II\Source; ..\..\Eval-ADUCM350EBZ\osal\uCOS-II\Ports; ..\..\uCOS-II-ADuCM350\Micrium\Software\uCOS-II\Source; ..\..\uCOS-II-ADuCM350\Micrium\Software\uCOS-II\Ports\ARM-Cortex-M3\CMSIS\IAR; ..\..\uCOS-II-ADuCM350\Micrium\Software\uC-CPU\ARM-Cortex-M3\IAR; ..\..\uCOS-II-ADuCM350\Micrium\Software\uC-CPU; ..\..\uCOS-II-ADuCM350\Micrium\Software\uC-CPU\Cfg\Template; ..\..\uCOS-II-ADuCM350\Micrium\Software\uC-LIB
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ImpedanceRtos.srec
  postbuild: "..\..\Eval-ADUCM350EBZ\tools\IElfTool\Debug_Win32_9\ielftool.exe" --fill 0xFF;0x0-0x5ffff --parity __parity0:0x1F00,even:0x00000000:L;0x0-0x3dfff --parity __parity1:0x0F80,even:0x00040000:L;0x40000-0x5efff --checksum __checksum0+0:4,crc32:LiR,0xffffffff;0x0-0x3fff7 --checksum __checksum0+4:4,crc32:Li,0xffffffff;0x0-0x3fff7 --checksum __checksum1+0:4,crc32:LiR,0xffffffff;0x40000-0x5fff7 --checksum __checksum1+4:4,crc32:Li,0xffffffff;0x40000-0x5fff7 "$TARGET_PATH$" "$TARGET_PATH$"
  ILINK.IlinkOutputFile: ImpedanceRtos.out
  ILINK.IlinkKeepSymbols: __checksum0; __checksum1; __parity0; __parity1
  ILINK.IlinkExtraOptions: --keep __checksum; --place_holder __checksum0,4,.checksum0,4; --place_holder __checksum1,4,.checksum1,4; --place_holder __parity0,0x1F00,.parity0,4; --place_holder __parity1,0x0F80,.parity1,4
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ARM_MATH_CM3; NDEBUG; RELOCATE_IVT; ADI_SYSTEM_CLOCK_TRANSITION; OSAL_DEBUG
  ICCARM.CCIncludePath2: ..; ..\..; ..\..\..\inc; ..\..\..\inc\config; ..\..\..\osal\uCOS-II\Source; ..\..\..\osal\uCOS-II\Ports; $_MICRIUM_DIR_$\uCOS-II\Source; $_MICRIUM_DIR_$\uCOS-II\Ports\ARM-Cortex-M3\CMSIS\IAR; $_MICRIUM_DIR_$\uC-CPU\ARM-Cortex-M3\IAR; $_MICRIUM_DIR_$\uC-CPU; $_MICRIUM_DIR_$\uC-CPU\Cfg\Template; $_MICRIUM_DIR_$\uC-LIB
  ICCARM.CCOptLevel: 3
  postbuild: "..\..\..\tools\IElfTool\Debug_Win32_9\ielftool.exe" --fill 0xFF;0x0-0x5ffff --parity __parity0:0x1F00,even:0x00000000:L;0x0-0x3dfff --parity __parity1:0x0F80,even:0x00040000:L;0x40000-0x5efff --checksum __checksum0+0:4,crc32:LiR,0xffffffff;0x0-0x3fff7 --checksum __checksum0+4:4,crc32:Li,0xffffffff;0x0-0x3fff7 --checksum __checksum1+0:4,crc32:LiR,0xffffffff;0x40000-0x5fff7 --checksum __checksum1+4:4,crc32:Li,0xffffffff;0x40000-0x5fff7 "$TARGET_PATH$" "$TARGET_PATH$"
  group (top)
    ../: Readme.txt
  group App Sources
    ../: adi_global_config.h app_hooks.c ImpedanceRtos.c ImpedanceRtos.h includes.h lib_cfg.h MainThread.c os_cfg.h PinMux.c PumpThread.c TransmitDataThread.c
    $_MICRIUM_DIR_$/Software/uC-CPU/ARM-Cortex-M3/IAR/: cpu_a.asm
    ../../Eval-ADUCM350EBZ/src/: test_common.c
  group Driver Soruces
    ../../Eval-ADUCM350EBZ/src/: adi_int.c adi_nvic.c afe.c beep.c captouch.c captouch_lib.c dma.c flash.c gpio.c gpt.c i2c.c i2s.c lcd.c rng.c rtc.c spi.c uart.c wdt.c wut.c
  group OSAL/Port
    ../../Eval-ADUCM350EBZ/osal/uCOS-II/Ports/: adi_osal_arch_c.c adi_osal_arch_int_table.c adi_osal_ucos2_arch_c.c
  group OSAL/Source
    ../../Eval-ADUCM350EBZ/osal/uCOS-II/Source/: adi_osal_ucos2.c adi_osal_ucos2_critical.c adi_osal_ucos2_event.c adi_osal_ucos2_init.c adi_osal_ucos2_message.c adi_osal_ucos2_mutex.c adi_osal_ucos2_rtl_lock.c adi_osal_ucos2_sem.c adi_osal_ucos2_thread.c adi_osal_ucos2_timing.c
  group System Sources
    ../../Eval-ADUCM350EBZ/src/: startup.c system.c
  group uC-CPU
    $_MICRIUM_DIR_$/Software/uC-CPU/: cpu_core.c
  group uC-CPU/IAR
    $_MICRIUM_DIR_$/Software/uC-CPU/ARM-Cortex-M3/IAR/: cpu_c.c
  group uCOS-II/Ports/CMSIS/IAR
    $_MICRIUM_DIR_$/Software/uCOS-II/Ports/ARM-Cortex-M3/CMSIS/IAR/: os_cpu_a.asm os_cpu_c.c
  group uCOS-II/Source
    $_MICRIUM_DIR_$/Software/uCOS-II/Source/: os_core.c os_dbg_r.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
