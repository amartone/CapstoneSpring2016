# IAR project libosal.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ADUCM350BBCZ AnalogDevices ADUCM350BBCZ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: DEBUG; ADI_DEBUG
  ICCARM.CCDiagSuppress: Pe040,Pe161,Pe618,Pa50
  ICCARM.CCIncludePath2: ..\..\..\..\inc; ..\..\..\..\inc\config; ..\..\Source; ..\..\Ports; $_MICRIUM_DIR_$\uCOS-II\Source; $_MICRIUM_DIR_$\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR; $_MICRIUM_DIR_$\uC-CPU; $_MICRIUM_DIR_$\uC-CPU\Cfg\Template; $_MICRIUM_DIR_$\uC-CPU\ARM-Cortex-M3\IAR
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: libosal.out
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group OSAL/Ports
    ../../Ports/: adi_osal_arch.h adi_osal_arch_c.c adi_osal_arch_int_table.c adi_osal_arch_internal.h adi_osal_ucos2_arch_c.c adi_types.h
  group OSAL/Source
    ../../Source/: adi_osal.h adi_osal_ucos2.c adi_osal_ucos2_critical.c adi_osal_ucos2_event.c adi_osal_ucos2_init.c adi_osal_ucos2_message.c adi_osal_ucos2_mutex.c adi_osal_ucos2_rtl_lock.c adi_osal_ucos2_sem.c adi_osal_ucos2_thread.c adi_osal_ucos2_timing.c adi_osal_ucos2_tls.c os_cfg.h osal_common.h osal_ucos.h version.h
